options:
  parameters:
    author: Barry Duggan
    description: packet receive
    generate_options: qt_gui
    id: pkt_rcv_strip
    output_language: python
    title: pkt_rcv_strip
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '2.0'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/maxwell/grcPackage/Bpsk-main/output.tmp
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: phase_bw
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '44'
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: phase_bw
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\nimport base64\n\nclass blk(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name='EPB: Decode Packet',   # will show up in GRC\n            in_sig=None,\n            out_sig=None)\n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.message_port_register_out(pmt.intern('msg_out'))\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)\n\n    def handle_msg(self, msg):\n        _debug = 0          # set to zero to turn off diagnostics\n        try:\n            buff = pmt.to_python(pmt.cdr(msg))\n        except Exception as e:\n            gr.log.error(\"Error with message conversion: %s\" % str(e))\n            return\n        b_len = len (buff)\n\n        if (buff[0] == 37):     # preamble or postamble\n            if ((buff[4] == 35) and (b_len < 52)):     # filename starts in buff[8]\n                print (\"End of text\")\n                if (_debug == 2):\n                    print (\"buff =\", buff, b_len)\n                intlist = np.frombuffer(buff, dtype=np.uint8)\n                ofn = ''.join(chr(i) for i in intlist[8:])  \n                print (\"Transmitted file name:\",ofn)\n\n        else:\n            # decode Base64\n            data = base64.b64decode(buff)\n            if (_debug == 1):\n                print (\"data =\", data)\n            pdu = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(data),list(data)))\n            self.message_port_pub(pmt.intern('msg_out'), pdu)\n\n"
    comment: |-
      Strip preamble and postamble
      Convert Base64 to original file content
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '34'
    bw0: 500e6
    dc_offset_mode0: '2'
    freq0: 5.8e9
    gain0: '5'
    gain_mode0: 'False'
    if_gain0: '48'
    sample_rate: usrp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 0,2,1,2
    gui_hint: 0,2,1,2
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 0,0,1,2
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,2
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,2,1,2
    gui_hint: 1,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    label1: ''
    name: Correlate input
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: (int)(usrp_rate/samp_rate)
    interp: '1'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49201
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_throttle2_0, '0', analog_agc_xx_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc32_bb_0_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_diff_decoder_bb_0, '0', virtual_sink_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_fll_band_edge_cc_0, '0', virtual_sink_0, '0']
- [digital_map_bb_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_map_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0, msg_out, pdu_pdu_to_tagged_stream_0, pdus]
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_0, msg_in]
- [rational_resampler_xxx_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_2, '0', digital_map_bb_0, '0']
- [zeromq_sub_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
